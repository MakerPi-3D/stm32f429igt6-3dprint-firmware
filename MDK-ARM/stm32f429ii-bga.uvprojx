# Keil uVision project stm32f429ii-bga.uvprojx, settings and files
target stm32f429ii-bga (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f429ii-bga +hex
  AfterMake: fromelf.exe --bin -o "..\..\WorkDir\PackIn\APP2.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,USE_USB_HS,ARM_MATH_CM4,__FPU_PRESENT=1U,__FPU_USED =1U,__USE_C99_MATH,CHECK_EXTRUDER_THERMISTOR_FALLS_OFF,CAL_Z_ZERO_OFFSET,USE_APP2
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../USB_HOST/App;../USB_HOST/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\libs\Inc;..\libs\Inc\Driver;..\libs\Inc\Function;..\libs\Inc\GUI\Control;..\libs\Inc\GUI\View;..\libs\Inc\Marlin;..\libs\Inc\Setting;..\libs\Inc\Task;..\libs\3d_engine\inc;..\libs\sysconfig\Inc;..\Drivers\CMSIS\DSP\Include;..\library\User\Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_hcd.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_sdram.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group UserAddon/User
    ../libs/Src/: globalvariables.c interface.c user_ccm.cpp
  group UserAddon/Setting
    ../libs/Src/Setting/: machine_custom.cpp machine_model.cpp machinecustom.cpp sysconfig_data.cpp
  group UserAddon/Marlin
    ../libs/Src/Marlin/: g1.cpp g2_g3.cpp g28.cpp g29.cpp g92.cpp process_command.cpp process_m_code.cpp t.cpp g1_dual_idex.cpp g1_laser.cpp g1_mix.cpp g29_abl.cpp m84.cpp m200-m205.cpp m301-m303.cpp m104_m109.cpp m140_m190.cpp m105.cpp m106_m107.cpp m92.cpp m114.cpp m600_m601.cpp m221.cpp gcode.cpp
  group UserAddon/GUI/View
    ../libs/Src/GUI/View/: gui_change_filament.cpp gui_common.cpp gui_door_open_warning.cpp gui_dual_extruder_setting.cpp gui_dual_home_pos_setting.cpp gui_dual_maindisplay.cpp gui_dual_printdisplay.cpp gui_dual_printset.cpp gui_dual_setting.cpp gui_filament_control_view.cpp gui_file_scan.cpp gui_main_display.cpp gui_material_check.cpp gui_measure_z_max_limit.cpp gui_move_xyz.cpp gui_no_udisk.cpp gui_pic_display.cpp gui_power_off_recover.cpp gui_prepare.cpp gui_print_confirm.cpp gui_print_finish.cpp gui_print_pause.cpp gui_print_set.cpp gui_print_stop.cpp gui_set_machine.cpp gui_setting.cpp gui_setting_p2_pro.cpp gui_status.cpp gui_warning_info.cpp guidata.c icons.c gui_waiting_page.cpp gui_p3_pro_setting.cpp gui_p3_pro_setting_idex.cpp gui_p3_pro_setting_ext1_comp.cpp gui_p3_pro_setting_home_pos.cpp gui_p3_pro_setting_ext_bed.cpp gui_p3_pro_idex_model_select.cpp gui_p3_pro_mix_model_select.cpp
  group UserAddon/GUI/Control
    ../libs/Src/GUI/Control/: guicontrol.cpp PrintControl.cpp RespondGUI.cpp UdiskControl.cpp USBFileTransfer.cpp
  group UserAddon/Function
    ../libs/Src/Function/: boardtest.cpp controlfunction.cpp controlxyz.cpp filamentcontrol.cpp functioncustom.cpp midwaychangematerial.cpp poweroffrecovery.cpp
  group UserAddon/Driver
    ../libs/Src/Driver/: ctiic.c ft5206.c touch.c
  group UserAddon/Task
    ../libs/Src/Task/: gui_task.cpp print_task.cpp read_udisk_task.cpp ref_data_task.cpp respond_gui_task.cpp start_default_task.cpp
  group 3d_engine_lib
    ../libs/3d_engine/src/: ConfigurationStore.cpp gcodebufferhandle.cpp grbl_acc_dec.cpp planner.cpp temperature.cpp stepper.cpp temperature_pid_autotune.cpp temperature_pid_output_factor.cpp temperature_pid_temp.cpp threed_engine.c vector_3.cpp planner_level.cpp
  group sysconfig
    ../libs/sysconfig/Src/: config_model_tables.cpp flashconfig.cpp sysconfig.cpp flash_poweroff_data.cpp
  group Library/User
    ../library/User/Src/: user_common.c user_ltdc.c user_uart1.c user_mcu.c user_os_msg.c user_board.c user_util.c user_usb_host.c user_usb_device.c user_delay.c user_iwdg.c user_sdram.c user_nand.c user_fan.c user_buzzer.c user_led.c
  group Library/Nand
    ../library/Nand/Src/: ftl.c nand.c
  group Library/Lcd
    ../library/Lcd/Src/: font.c lcd.c ltdc.c
  group Library/Iap
    ../library/Iap/Src/: command.c flash_if.c iap_menu.c
  group Library/Feature
    ../library/Feature/Src/: filament_check.cpp fan_control.cpp led_control.cpp
software components: CMSIS:CORE 5.4.0
